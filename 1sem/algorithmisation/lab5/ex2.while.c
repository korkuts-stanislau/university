#include <stdio.h>
#include <math.h>

	float x0,xk,footX,x,y;
    int n=1;
    
int main(){
   puts("Enter the first X");
   scanf("%f",&x0);
   puts("Enter the last X");
   scanf("%f",&xk);
   puts("Enter the foot of X");
   scanf("%f",&footX);
   
   puts("\xC9\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCB\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCB"
         "\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xBB");
   puts("\xBA   N   \xBA      X      \xBA       Y       \xBA");
   puts("\xCC\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCE\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCE\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xB9");
   
   
   
   x = x0;
   
   while(x <= xk){
	   		if(x>=10){
			   	y=x*x-log(x);
			}
			else if(x<=0){
					y=pow((sin(x)*sin(x)+x*x),0.5);
			}
			else{
					y=log(x)*log(x)+x/2;
			}
			printf("\xBA  %3d  \xBA   %7.2f   \xBA   %9.2f   \xBA\n",n,x,y);
			n++;
			x += footX;
   }
   
   puts("\xC8\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCA\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCA\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xCD\xBC");

   
   getch();
   return 0;
}


